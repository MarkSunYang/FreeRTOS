# Keil uVision project FirstFreeRTOS.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: FirstFreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\FirstFreeRTOS.sct
  group user
    ./: main.c
  group doc
    ./: readme.txt
  group FreeRTOS/Source
    ./: list.c list.h FreeRTOSConfig.h portmacro.h FreeRTOS.h task.c task.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.2.0
